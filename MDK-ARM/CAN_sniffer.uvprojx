# Keil uVision project CAN_sniffer.uvprojx, settings and files
target CAN_sniffer (6190000::V6.19::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CAN_sniffer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: -Wno-padded -Wno-implicit-int-conversion -Wno-declaration-after-statement -Wno-missing-prototypes -Wno-cast-align -Wno-unused-function -Wno-missing-field-initializers -Wno-sign-conversion -Wno-implicit-fallthrough -Wno-extra-semi-stmt -Wno-newline-eof -Wno-cast-qual -Wno-assign-enum -Wno-switch-enum -Wno-missing-variable-declarations -Wno-unreachable-code-return -Wno-unused-parameter -Wno-missing-noreturn -Wno-disabled-macro-expansion -Wno-covered-switch-default -Wno-shorten-64-to-32 -Wno-invalid-utf8 -Wno-format-nonliteral -Wno-unreachable-code -Wno-bad-function-cast -Wno-comma -Wno-bitfield-enum-conversion -Wno-unreachable-code-break
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/lvgl;../Middlewares/Third_Party/lvgl/include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/BSP/STM32746G-Discovery;../Drivers/BSP/Components/lan8742;../Drivers/BSP/Components/n25q128a
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\CAN_sniffer.sct
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c platform.c can_capture.c can_tx_manager.c canopen_decoder.c canopen_analyzer.c can_log.c sdmmc.c sd_diskio.c touch_ft5336.c ui.c ui_font_cyrillic_14.c gpio.c freertos.c can.c dma2d.c fmc.c i2c.c ltdc.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c device_settings.c qspi_store.c app_settings.c web_assets.c network_service.c api_server.c ethernetif.c retarget_io.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sram.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_eth.c stm32f7xx_hal_qspi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/LVGL
    ../Middlewares/Third_Party/lvgl/src/fs/: lv_fs.c
    ../Middlewares/Third_Party/lvgl/src/image/: lv_image_decoder.c lv_bin_decoder.c
    ../Middlewares/Third_Party/lvgl/src/: lv_init.c
    ../Middlewares/Third_Party/lvgl/src/core/: lv_group.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_observer.c lv_refr.c
    ../Middlewares/Third_Party/lvgl/src/display/: lv_display.c
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c lv_draw.c
    ../Middlewares/Third_Party/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask_rect.c lv_draw_sw_mask.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c lv_draw_sw.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/: lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14_aligned.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ../Middlewares/Third_Party/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/Third_Party/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/Third_Party/lvgl/src/font/font_manager/: lv_font_manager_recycle.c lv_font_manager.c
    ../Middlewares/Third_Party/lvgl/src/font/freetype/: lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    ../Middlewares/Third_Party/lvgl/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/Third_Party/lvgl/src/indev/: lv_gridnav.c lv_indev_gesture.c lv_indev_scroll.c lv_indev.c
    ../Middlewares/Third_Party/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl/src/logging/: lv_log.c
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_array.c lv_async.c lv_bidi_common.c lv_bidi.c lv_circle_buf.c lv_color_op.c lv_color.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style_gen.c lv_style.c lv_templ.c lv_text_ap.c lv_text.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/: lv_cache_entry.c lv_cache.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os_none.c lv_os.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/Third_Party/lvgl/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/lvgl/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/Third_Party/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/Third_Party/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/Third_Party/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/Third_Party/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/Third_Party/lvgl/src/widgets/barcode/: lv_barcode.c
    ../Middlewares/Third_Party/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/Third_Party/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/Third_Party/lvgl/src/widgets/calendar/: lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../Middlewares/Third_Party/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/Third_Party/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/lvgl/src/widgets/gif/: lv_gif.c
    ../Middlewares/Third_Party/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
    ../Middlewares/Third_Party/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/Third_Party/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/Third_Party/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/Third_Party/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/Third_Party/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/Third_Party/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/Third_Party/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../Middlewares/Third_Party/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/Third_Party/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/Third_Party/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/Third_Party/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/Third_Party/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/Third_Party/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/Third_Party/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl/src/widgets/win/: lv_win.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: unicode.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
  group Drivers/BSP
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_qspi.c
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netbuf.c api_lib.c tcpip.c netifapi.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/core/: timeouts.c udp.c ip.c def.c raw.c stats.c memp.c init.c sys.c pbuf.c netif.c tcp_out.c tcp.c mem.c inet_chksum.c tcp_in.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c icmp.c ip4.c ip4_addr.c ip4_frag.c dhcp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
software components: CMSIS:CORE 4.3.0
